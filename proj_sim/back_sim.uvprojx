# Keil uVision project back_sim.uvprojx, settings and files
target LPC11C14 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  group Source Files
    ./RTE/Device/LPC11C14FBD48_301/: system_LPC11xx.c
    ./Src/: startup_ARMCM0.S back_sim.c back.s
